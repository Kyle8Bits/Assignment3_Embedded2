# Keil uVision project Question2_Indi.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.16
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Question2_Indi
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000

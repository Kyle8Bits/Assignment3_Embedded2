# Keil uVision project Assignment3_Question2.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.16
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Assignment3_Question2
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Program Files\Program_Keil\Keil_v5\Library\StdDriver\Include;C:\Program Files\Program_Keil\Keil_v5\Library\NuMakerLib\Include;C:\Program Files\Program_Keil\Keil_v5\Library\NUC100Series\Include;C:\Program Files\Program_Keil\Keil_v5\Library\NUC1xx-LB_002\Include;C:\Program Files\Program_Keil\Keil_v5\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group UserSources
    ./: main.c
  group System Sources
    C:/Program Files/Program_Keil/Keil_v5/Library/NUC100Series/Source/: system_NUC100Series.c
    C:/Program Files/Program_Keil/Keil_v5/Library/NUC100Series/Source/ARM/: startup_NUC100Series.s
    C:/Program Files/Program_Keil/Keil_v5/Library/StdDriver/Source/: gpio.c clk.c sys.c
    C:/Program Files/Program_Keil/Keil_v5/Library/NuMakerLib/Source/: SYS_init.c
  group User Headers
    ./: displayDigit.h setupGPIO.h enableClockSource.h enableTimer0.h clockState.h setupKeyMatrix.h
